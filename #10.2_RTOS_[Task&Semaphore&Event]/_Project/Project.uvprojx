# Keil uVision project Project.uvprojx, settings and files
target 1986VE92 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: 1986VE92 Milandr
  pack: Keil.Milandr_1986VE9x.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1986VE92 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Libraries\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main Group
    ../Source/: main.c led.c rtos.c
  group Libraries
    ../../Libraries/: lib_clk.c lib_btn.c
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, Device:Startup 1.0
